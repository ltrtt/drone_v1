# Keil uVision project Flight control.uvprojx, settings and files
target Flight Control (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Flight control +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,MPL_LOG_NDEBUG=1,EMPL,MPU9250,EMPL_TARGET_STM32F4
  c misc: --diag_suppress=1
  c include: .\USER;.\FWLIB\inc;.\CORE;.\Hardware;.\DMP\driver\eMPL;.\DMP\driver\include;.\DMP\mpl;.\DMP\mllite;.\DMP\eMPL-hal;.\DMP\driver\stm32L
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: main.c sys_function.c system_stm32f4xx.c stm32f4xx_it.c pid.c
    ./Hardware/: adc.c
  group CORE
    ./CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ./FWLIB/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c misc.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_adc.c stm32f4xx_spi.c
  group HARDWARE
    ./Hardware/: Usart.c bmp280_driver.c mpu9250_driver.c bmp280.c mpu9250.c usart2.c nrf2401.c
  group DMP
    ./DMP/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./DMP/driver/stm32L/: log_stm32.c
    ./DMP/eMPL-hal/: eMPL_outputs.c
    ./DMP/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ./DMP/mpl/: libmpllib.lib
